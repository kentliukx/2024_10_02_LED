<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\2024_10_02_LED.ewp</path>
  </project>
  <batchBuild />
</workspace>
